# IAR project Cental.ewp, settings and files
configuration CC2541 (8051, debug)
  General.OGChipSelectMenu: CC2541F256 CC2541F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=2; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_ADC=TRUE; CC2541; HAL_UART_DMA=2; HAL_UART=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\ble\common; ..\..\ble\include; ..\..\..\Components\hal\include; ..\..\..\Components\hal\target\CC2541ST; ..\..\..\Components\osal\include; ..\..\..\Components\services\saddr; ..\..\..\Components\ble\include; ..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\Components\ble\controller\CC254x\include; ..\..\..\Components\ble\hci; ..\..\..\Components\ble\host; ..\..\..\Components\ble\ROM; ..\..\ble\common\cc2540; ..\..\ble\common\npi\npi_np; ..\..\ble\Profiles\Roles\CC254x; ..\..\ble\Profiles\Roles; ..\..\ble\Profiles\SimpleProfile\CC254x; ..\..\ble\Profiles\SimpleProfile; ..\..\ble\Profiles\DevInfo; ..\..\ble\Profiles\Keys\CC254x; ..\..\ble\Profiles\Keys; ..\Source; ..\..\..\..\STM32F4_MotorControl\MyLibs\MyMsg
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\ble\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c simpleBLEPeripheral.h SimpleBLEPeripheral_Main.c TestTask.c TestTask.h
  group HAL/Common
    ../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540EB/Config
    ../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../Components/ble/host/: linkdb.h
    ../../../Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../ble/common/npi/npi_np/: npi.h
  group LIB
    ../../ble/Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../ble/Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../ble/common/npi/npi_np/: npi.c
  group NPI/MyLibs/MyMsg
    ../../../../STM32F4_MotorControl/MyLibs/MyMsg/: msg.c MyMsg.h
  group OSAL
    ../../../Components/ble/include/: bcomdef.h
    ../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../ble/Profiles/DevInfo/: devinfoservice.c devinfoservice.h
    ../../ble/Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h peripheralBroadcaster.c peripheralBroadcaster.h
    ../../ble/Include/: gapgattserver.h gattservapp.h
    ../../../Components/ble/host/: gatt_uuid.c
    ../../ble/Profiles/GATT/: gattservapp_util.c
    ../../ble/Profiles/OAD/: oad.h oad_target.c oad_target.h
    ../../ble/Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../../ble/Profiles/SimpleProfile/CC254x/: simpleGATTprofile.c
    ../../ble/Profiles/SimpleProfile/: SIMPLEgattPROFILE.h
    ../../ble/Profiles/Keys/CC254x/: simplekeys.c
    ../../ble/Profiles/Keys/: simplekeys.h
  group TOOLS
    ../../ble/config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../ble/common/cc2540/: OnBoard.c OnBoard.h
